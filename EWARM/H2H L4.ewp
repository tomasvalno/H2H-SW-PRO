# IAR project H2H L4.ewp, settings and files
configuration H2H L4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L486VG ST STM32L486VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L486xx
  ICCARM.CCIncludePath2: ../Inc; ../H2H-Devices/STM32L4xx_HAL_Driver/Inc; ../H2H-Devices/STM32L4xx_HAL_Driver/Inc/Legacy; ../FreeRTOS/portable/IAR/ARM_CM4F; ../H2H-Devices/CMSIS/Device/ST/STM32L4xx/Include; ../FreeRTOS/Include; ../H2H-Devices/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: H2H L4.out
  ILINK.IlinkIcfFile: stm32l486xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l486xx.s
  group Application/User
    ../Src/: dma.c fmc.c freertos.c gpio.c i2c.c main.c rtc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../H2H-Devices/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../H2H-Devices/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_fmc.c
  group FreeRTOS
    ../FreeRTOS/Source/: cmsis_os.c croutine.c event_groups.c heap_4.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
